# Keil uVision project OS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: OS
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER
  c include: ..\APP;..\STMLIB\inc;..\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../APP/: main.c serial.c app_led.c uarttest.c
  group LIB
    ../STMLIB/src/: misc.c stm32f2xx_gpio.c stm32f2xx_it.c stm32f2xx_rcc.c system_stm32f2xx.c stm32f2xx_usart.c
    ../STMLIB/startup/: cstartup.s
  group OS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c

# Keil uVision project OS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER
  c include: ..\APP;..\STMLIB\inc;..\FreeRTOS\include;..\APP\cli;..\DRV;..\LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../APP/: main.c serial.c app_led.c
    ../APP/cli/: app_cli.c mid_cli.c hal_cli.c
  group STLIB
    ../STMLIB/src/: misc.c stm32f2xx_gpio.c stm32f2xx_it.c stm32f2xx_rcc.c system_stm32f2xx.c stm32f2xx_usart.c stm32f2xx_i2c.c stm32f2xx_dma.c
    ../STMLIB/startup/: cstartup.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group DRV
    ../DRV/: vfs_i2c.c i2c_bus.c
  group LIB
    ../LIB/: vfs.c vfs_file.c vfs_inode.c vfs_register.c
software components: CMSIS:CORE 5.1.1
